CBADC OpAmpTestbench
* This file was autogenerated using the
* cbadc toolbox, see https://github.com/hammal/cbadc
* and is thereby valid under the
*
* GNU General Public License v3.0
* (see https://github.com/hammal/cbadc/blob/main/LICENCE)
*
* This file was generated at
*
* 2024-01-24T10:36:40.517996
*
* using the cbadc package version
*
* 0.3.1
*

* globals
.GLOBAL gnd 0

* power supply
Vdd VDD VCM DC 0.5
Vss VCM 0 DC 0.5

* system clock
Vclk CLK 0 PULSE(0.0 1.0 0.0 1e-14 1e-14 2.3282064365386962e-10 4.656612873077393e-10) DC 0.0

* input signal(s)
Vin_p_0 IN0_P VCM SIN(0.0 0.45 738197504.0 0.0 0.0 3.141592653589793) DC 0.0 AC 0.5
Vin_n_0 VCM IN0_N SIN(0.0 0.45 738197504.0 0.0 0.0 3.141592653589793) DC 0.0 AC 0.5
Vin_p_1 IN1_P VCM SIN(0.0 0.45 738197504.0 0.0 0.0 1.5707963267948966) DC 0.0 AC 0.5
Vin_n_1 VCM IN1_N SIN(0.0 0.45 738197504.0 0.0 0.0 1.5707963267948966) DC 0.0 AC 0.5

* analog frontend
Xaf 0 VDD CLK VCM IN0_P IN1_P IN0_N IN1_N OUT0_P OUT1_P OUT2_P OUT3_P OUT4_P OUT5_P OUT6_P OUT7_P OUT8_P OUT9_P OUT10_P OUT11_P OUT12_P OUT13_P OUT0_N OUT1_N OUT2_N OUT3_N OUT4_N OUT5_N OUT6_N OUT7_N OUT8_N OUT9_N OUT10_N OUT11_N OUT12_N OUT13_N opamp_analog_frontend

* sub circuits
.SUBCKT opamp_analog_frontend VSS VDD CLK VCM IN0_P IN1_P IN0_N IN1_N OUT0_P OUT1_P OUT2_P OUT3_P OUT4_P OUT5_P OUT6_P OUT7_P OUT8_P OUT9_P OUT10_P OUT11_P OUT12_P OUT13_P OUT0_N OUT1_N OUT2_N OUT3_N OUT4_N OUT5_N OUT6_N OUT7_N OUT8_N OUT9_N OUT10_N OUT11_N OUT12_N OUT13_N
    Xdc VSS VDD CLK VCM X0_P X1_P X2_P X3_P X4_P X5_P X6_P X7_P X8_P X9_P X10_P X11_P X0_N X1_N X2_N X3_N X4_N X5_N X6_N X7_N X8_N X9_N X10_N X11_N IN0_P IN1_P IN0_N IN1_N OUT0_P OUT1_P OUT2_P OUT3_P OUT4_P OUT5_P OUT6_P OUT7_P OUT8_P OUT9_P OUT10_P OUT11_P OUT12_P OUT13_P OUT0_N OUT1_N OUT2_N OUT3_N OUT4_N OUT5_N OUT6_N OUT7_N OUT8_N OUT9_N OUT10_N OUT11_N OUT12_N OUT13_N dither_control
    Rp_b_0_0 IN0_P VGND_0_N r=931.3225746154785
    Rn_b_0_0 IN0_N VGND_0_P r=931.3225746154785
    Rp_b_6_1 IN1_P VGND_6_N r=931.3225746154785
    Rn_b_6_1 IN1_N VGND_6_P r=931.3225746154785
    Rp_a_0_1 X1_P VGND_0_P r=6039.213159223663
    Rn_a_0_1 X1_N VGND_0_N r=6039.213159223663
    Rp_a_0_6 X6_P VGND_0_P r=237.1593461809983
    Rn_a_0_6 X6_N VGND_0_N r=237.1593461809983
    Rp_a_1_0 X0_P VGND_1_N r=931.3225746154785
    Rn_a_1_0 X0_N VGND_1_P r=931.3225746154785
    Rp_a_1_2 X2_P VGND_1_P r=6039.213159223663
    Rn_a_1_2 X2_N VGND_1_N r=6039.213159223663
    Rp_a_1_7 X7_P VGND_1_P r=237.1593461809983
    Rn_a_1_7 X7_N VGND_1_N r=237.1593461809983
    Rp_a_2_1 X1_P VGND_2_N r=931.3225746154785
    Rn_a_2_1 X1_N VGND_2_P r=931.3225746154785
    Rp_a_2_3 X3_P VGND_2_P r=6039.213159223663
    Rn_a_2_3 X3_N VGND_2_N r=6039.213159223663
    Rp_a_2_8 X8_P VGND_2_P r=237.1593461809983
    Rn_a_2_8 X8_N VGND_2_N r=237.1593461809983
    Rp_a_3_2 X2_P VGND_3_N r=931.3225746154785
    Rn_a_3_2 X2_N VGND_3_P r=931.3225746154785
    Rp_a_3_4 X4_P VGND_3_P r=6039.213159223663
    Rn_a_3_4 X4_N VGND_3_N r=6039.213159223663
    Rp_a_3_9 X9_P VGND_3_P r=237.1593461809983
    Rn_a_3_9 X9_N VGND_3_N r=237.1593461809983
    Rp_a_4_3 X3_P VGND_4_N r=931.3225746154785
    Rn_a_4_3 X3_N VGND_4_P r=931.3225746154785
    Rp_a_4_5 X5_P VGND_4_P r=6039.213159223663
    Rn_a_4_5 X5_N VGND_4_N r=6039.213159223663
    Rp_a_4_10 X10_P VGND_4_P r=237.1593461809983
    Rn_a_4_10 X10_N VGND_4_N r=237.1593461809983
    Rp_a_5_4 X4_P VGND_5_N r=931.3225746154785
    Rn_a_5_4 X4_N VGND_5_P r=931.3225746154785
    Rp_a_5_11 X11_P VGND_5_P r=237.1593461809983
    Rn_a_5_11 X11_N VGND_5_N r=237.1593461809983
    Rp_a_6_0 X0_P VGND_6_N r=237.1593461809983
    Rn_a_6_0 X0_N VGND_6_P r=237.1593461809983
    Rp_a_6_7 X7_P VGND_6_P r=6039.213159223663
    Rn_a_6_7 X7_N VGND_6_N r=6039.213159223663
    Rp_a_7_1 X1_P VGND_7_N r=237.1593461809983
    Rn_a_7_1 X1_N VGND_7_P r=237.1593461809983
    Rp_a_7_6 X6_P VGND_7_N r=931.3225746154785
    Rn_a_7_6 X6_N VGND_7_P r=931.3225746154785
    Rp_a_7_8 X8_P VGND_7_P r=6039.213159223663
    Rn_a_7_8 X8_N VGND_7_N r=6039.213159223663
    Rp_a_8_2 X2_P VGND_8_N r=237.1593461809983
    Rn_a_8_2 X2_N VGND_8_P r=237.1593461809983
    Rp_a_8_7 X7_P VGND_8_N r=931.3225746154785
    Rn_a_8_7 X7_N VGND_8_P r=931.3225746154785
    Rp_a_8_9 X9_P VGND_8_P r=6039.213159223663
    Rn_a_8_9 X9_N VGND_8_N r=6039.213159223663
    Rp_a_9_3 X3_P VGND_9_N r=237.1593461809983
    Rn_a_9_3 X3_N VGND_9_P r=237.1593461809983
    Rp_a_9_8 X8_P VGND_9_N r=931.3225746154785
    Rn_a_9_8 X8_N VGND_9_P r=931.3225746154785
    Rp_a_9_10 X10_P VGND_9_P r=6039.213159223663
    Rn_a_9_10 X10_N VGND_9_N r=6039.213159223663
    Rp_a_10_4 X4_P VGND_10_N r=237.1593461809983
    Rn_a_10_4 X4_N VGND_10_P r=237.1593461809983
    Rp_a_10_9 X9_P VGND_10_N r=931.3225746154785
    Rn_a_10_9 X9_N VGND_10_P r=931.3225746154785
    Rp_a_10_11 X11_P VGND_10_P r=6039.213159223663
    Rn_a_10_11 X11_N VGND_10_N r=6039.213159223663
    Rp_a_11_5 X5_P VGND_11_N r=237.1593461809983
    Rn_a_11_5 X5_N VGND_11_P r=237.1593461809983
    Rp_a_11_10 X10_P VGND_11_N r=931.3225746154785
    Rn_a_11_10 X10_N VGND_11_P r=931.3225746154785
    Rp_gamma_0_0 OUT0_P VGND_0_N r=7887.631584921591
    Rn_gamma_0_0 OUT0_N VGND_0_P r=7887.631584921591
    Rp_gamma_0_2 OUT2_P VGND_0_N r=788.763158492159
    Rn_gamma_0_2 OUT2_N VGND_0_P r=788.763158492159
    Rp_gamma_1_3 OUT3_P VGND_1_N r=788.763158492159
    Rn_gamma_1_3 OUT3_N VGND_1_P r=788.763158492159
    Rp_gamma_2_4 OUT4_P VGND_2_N r=788.763158492159
    Rn_gamma_2_4 OUT4_N VGND_2_P r=788.763158492159
    Rp_gamma_3_5 OUT5_P VGND_3_N r=788.763158492159
    Rn_gamma_3_5 OUT5_N VGND_3_P r=788.763158492159
    Rp_gamma_4_6 OUT6_P VGND_4_N r=788.763158492159
    Rn_gamma_4_6 OUT6_N VGND_4_P r=788.763158492159
    Rp_gamma_5_7 OUT7_P VGND_5_N r=788.763158492159
    Rn_gamma_5_7 OUT7_N VGND_5_P r=788.763158492159
    Rp_gamma_6_1 OUT1_P VGND_6_N r=7887.631584921591
    Rn_gamma_6_1 OUT1_N VGND_6_P r=7887.631584921591
    Rp_gamma_6_8 OUT8_P VGND_6_N r=788.763158492159
    Rn_gamma_6_8 OUT8_N VGND_6_P r=788.763158492159
    Rp_gamma_7_9 OUT9_P VGND_7_N r=788.763158492159
    Rn_gamma_7_9 OUT9_N VGND_7_P r=788.763158492159
    Rp_gamma_8_10 OUT10_P VGND_8_N r=788.763158492159
    Rn_gamma_8_10 OUT10_N VGND_8_P r=788.763158492159
    Rp_gamma_9_11 OUT11_P VGND_9_N r=788.763158492159
    Rn_gamma_9_11 OUT11_N VGND_9_P r=788.763158492159
    Rp_gamma_10_12 OUT12_P VGND_10_N r=788.763158492159
    Rn_gamma_10_12 OUT12_N VGND_10_P r=788.763158492159
    Rp_gamma_11_13 OUT13_P VGND_11_N r=788.763158492159
    Rn_gamma_11_13 OUT13_N VGND_11_P r=788.763158492159
    Xop_0 VDD VSS VCM VGND_0_P VGND_0_N X0_P X0_N opamp
    Xop_1 VDD VSS VCM VGND_1_P VGND_1_N X1_P X1_N opamp
    Xop_2 VDD VSS VCM VGND_2_P VGND_2_N X2_P X2_N opamp
    Xop_3 VDD VSS VCM VGND_3_P VGND_3_N X3_P X3_N opamp
    Xop_4 VDD VSS VCM VGND_4_P VGND_4_N X4_P X4_N opamp
    Xop_5 VDD VSS VCM VGND_5_P VGND_5_N X5_P X5_N opamp
    Xop_6 VDD VSS VCM VGND_6_P VGND_6_N X6_P X6_N opamp
    Xop_7 VDD VSS VCM VGND_7_P VGND_7_N X7_P X7_N opamp
    Xop_8 VDD VSS VCM VGND_8_P VGND_8_N X8_P X8_N opamp
    Xop_9 VDD VSS VCM VGND_9_P VGND_9_N X9_P X9_N opamp
    Xop_10 VDD VSS VCM VGND_10_P VGND_10_N X10_P X10_N opamp
    Xop_11 VDD VSS VCM VGND_11_P VGND_11_N X11_P X11_N opamp
    Cp_0 VGND_0_P X0_P 1e-12
    Cp_1 VGND_1_P X1_P 1e-12
    Cp_2 VGND_2_P X2_P 1e-12
    Cp_3 VGND_3_P X3_P 1e-12
    Cp_4 VGND_4_P X4_P 1e-12
    Cp_5 VGND_5_P X5_P 1e-12
    Cp_6 VGND_6_P X6_P 1e-12
    Cp_7 VGND_7_P X7_P 1e-12
    Cp_8 VGND_8_P X8_P 1e-12
    Cp_9 VGND_9_P X9_P 1e-12
    Cp_10 VGND_10_P X10_P 1e-12
    Cp_11 VGND_11_P X11_P 1e-12
    Cn_0 VGND_0_N X0_N 1e-12
    Cn_1 VGND_1_N X1_N 1e-12
    Cn_2 VGND_2_N X2_N 1e-12
    Cn_3 VGND_3_N X3_N 1e-12
    Cn_4 VGND_4_N X4_N 1e-12
    Cn_5 VGND_5_N X5_N 1e-12
    Cn_6 VGND_6_N X6_N 1e-12
    Cn_7 VGND_7_N X7_N 1e-12
    Cn_8 VGND_8_N X8_N 1e-12
    Cn_9 VGND_9_N X9_N 1e-12
    Cn_10 VGND_10_N X10_N 1e-12
    Cn_11 VGND_11_N X11_N 1e-12
.ENDS opamp_analog_frontend

.SUBCKT dither_control VSS VDD CLK VCM X0_P X1_P X2_P X3_P X4_P X5_P X6_P X7_P X8_P X9_P X10_P X11_P X0_N X1_N X2_N X3_N X4_N X5_N X6_N X7_N X8_N X9_N X10_N X11_N IN0_P IN1_P IN0_N IN1_N S0_P S1_P S2_P S3_P S4_P S5_P S6_P S7_P S8_P S9_P S10_P S11_P S12_P S13_P S0_N S1_N S2_N S3_N S4_N S5_N S6_N S7_N S8_N S9_N S10_N S11_N S12_N S13_N
    Xdc VSS VDD CLK VCM X0_P X1_P X2_P X3_P X4_P X5_P X6_P X7_P X8_P X9_P X10_P X11_P X0_N X1_N X2_N X3_N X4_N X5_N X6_N X7_N X8_N X9_N X10_N X11_N IN0_P IN1_P IN0_N IN1_N S0_P S1_P S2_P S3_P S4_P S5_P S6_P S7_P S8_P S9_P S10_P S11_P S12_P S13_P S0_N S1_N S2_N S3_N S4_N S5_N S6_N S7_N S8_N S9_N S10_N S11_N S12_N S13_N digital_control
    Ars [RS_0 RS_1] r_source
    Aclk_adc [CLK] [OUT] adc
    Adffp_0 RS_0 OUT SET RES F_OUT_P F_OUT_N dflip
    Adffp_1 RS_1 OUT SET RES F_OUT_P F_OUT_N dflip
    Adac_p_0 [F_OUT_P] [S0_P] dac
    Adac_p_1 [F_OUT_P] [S1_P] dac
    Adac_n_0 [F_OUT_N] [S0_N] dac
    Adac_n_1 [F_OUT_N] [S1_N] dac
.ENDS dither_control

.SUBCKT digital_control VSS VDD CLK VCM X0_P X1_P X2_P X3_P X4_P X5_P X6_P X7_P X8_P X9_P X10_P X11_P X0_N X1_N X2_N X3_N X4_N X5_N X6_N X7_N X8_N X9_N X10_N X11_N IN0_P IN1_P IN0_N IN1_N S0_P S1_P S2_P S3_P S4_P S5_P S6_P S7_P S8_P S9_P S10_P S11_P S12_P S13_P S0_N S1_N S2_N S3_N S4_N S5_N S6_N S7_N S8_N S9_N S10_N S11_N S12_N S13_N
    Xmic_2 VSS VDD CLK VCM X0_P X1_P X2_P X3_P X4_P X5_P X6_P X7_P X8_P X9_P X10_P X11_P X0_N X1_N X2_N X3_N X4_N X5_N X6_N X7_N X8_N X9_N X10_N X11_N IN0_P IN1_P IN0_N IN1_N S0_P S1_P S2_P S3_P S4_P S5_P S6_P S7_P S8_P S9_P S10_P S11_P S12_P S13_P S0_N S1_N S2_N S3_N S4_N S5_N S6_N S7_N S8_N S9_N S10_N S11_N S12_N S13_N multi_input_comparator_2
    Xmic_3 VSS VDD CLK VCM X0_P X1_P X2_P X3_P X4_P X5_P X6_P X7_P X8_P X9_P X10_P X11_P X0_N X1_N X2_N X3_N X4_N X5_N X6_N X7_N X8_N X9_N X10_N X11_N IN0_P IN1_P IN0_N IN1_N S0_P S1_P S2_P S3_P S4_P S5_P S6_P S7_P S8_P S9_P S10_P S11_P S12_P S13_P S0_N S1_N S2_N S3_N S4_N S5_N S6_N S7_N S8_N S9_N S10_N S11_N S12_N S13_N multi_input_comparator_3
    Xmic_4 VSS VDD CLK VCM X0_P X1_P X2_P X3_P X4_P X5_P X6_P X7_P X8_P X9_P X10_P X11_P X0_N X1_N X2_N X3_N X4_N X5_N X6_N X7_N X8_N X9_N X10_N X11_N IN0_P IN1_P IN0_N IN1_N S0_P S1_P S2_P S3_P S4_P S5_P S6_P S7_P S8_P S9_P S10_P S11_P S12_P S13_P S0_N S1_N S2_N S3_N S4_N S5_N S6_N S7_N S8_N S9_N S10_N S11_N S12_N S13_N multi_input_comparator_4
    Xmic_5 VSS VDD CLK VCM X0_P X1_P X2_P X3_P X4_P X5_P X6_P X7_P X8_P X9_P X10_P X11_P X0_N X1_N X2_N X3_N X4_N X5_N X6_N X7_N X8_N X9_N X10_N X11_N IN0_P IN1_P IN0_N IN1_N S0_P S1_P S2_P S3_P S4_P S5_P S6_P S7_P S8_P S9_P S10_P S11_P S12_P S13_P S0_N S1_N S2_N S3_N S4_N S5_N S6_N S7_N S8_N S9_N S10_N S11_N S12_N S13_N multi_input_comparator_5
    Xmic_6 VSS VDD CLK VCM X0_P X1_P X2_P X3_P X4_P X5_P X6_P X7_P X8_P X9_P X10_P X11_P X0_N X1_N X2_N X3_N X4_N X5_N X6_N X7_N X8_N X9_N X10_N X11_N IN0_P IN1_P IN0_N IN1_N S0_P S1_P S2_P S3_P S4_P S5_P S6_P S7_P S8_P S9_P S10_P S11_P S12_P S13_P S0_N S1_N S2_N S3_N S4_N S5_N S6_N S7_N S8_N S9_N S10_N S11_N S12_N S13_N multi_input_comparator_6
    Xmic_7 VSS VDD CLK VCM X0_P X1_P X2_P X3_P X4_P X5_P X6_P X7_P X8_P X9_P X10_P X11_P X0_N X1_N X2_N X3_N X4_N X5_N X6_N X7_N X8_N X9_N X10_N X11_N IN0_P IN1_P IN0_N IN1_N S0_P S1_P S2_P S3_P S4_P S5_P S6_P S7_P S8_P S9_P S10_P S11_P S12_P S13_P S0_N S1_N S2_N S3_N S4_N S5_N S6_N S7_N S8_N S9_N S10_N S11_N S12_N S13_N multi_input_comparator_7
    Xmic_8 VSS VDD CLK VCM X0_P X1_P X2_P X3_P X4_P X5_P X6_P X7_P X8_P X9_P X10_P X11_P X0_N X1_N X2_N X3_N X4_N X5_N X6_N X7_N X8_N X9_N X10_N X11_N IN0_P IN1_P IN0_N IN1_N S0_P S1_P S2_P S3_P S4_P S5_P S6_P S7_P S8_P S9_P S10_P S11_P S12_P S13_P S0_N S1_N S2_N S3_N S4_N S5_N S6_N S7_N S8_N S9_N S10_N S11_N S12_N S13_N multi_input_comparator_8
    Xmic_9 VSS VDD CLK VCM X0_P X1_P X2_P X3_P X4_P X5_P X6_P X7_P X8_P X9_P X10_P X11_P X0_N X1_N X2_N X3_N X4_N X5_N X6_N X7_N X8_N X9_N X10_N X11_N IN0_P IN1_P IN0_N IN1_N S0_P S1_P S2_P S3_P S4_P S5_P S6_P S7_P S8_P S9_P S10_P S11_P S12_P S13_P S0_N S1_N S2_N S3_N S4_N S5_N S6_N S7_N S8_N S9_N S10_N S11_N S12_N S13_N multi_input_comparator_9
    Xmic_10 VSS VDD CLK VCM X0_P X1_P X2_P X3_P X4_P X5_P X6_P X7_P X8_P X9_P X10_P X11_P X0_N X1_N X2_N X3_N X4_N X5_N X6_N X7_N X8_N X9_N X10_N X11_N IN0_P IN1_P IN0_N IN1_N S0_P S1_P S2_P S3_P S4_P S5_P S6_P S7_P S8_P S9_P S10_P S11_P S12_P S13_P S0_N S1_N S2_N S3_N S4_N S5_N S6_N S7_N S8_N S9_N S10_N S11_N S12_N S13_N multi_input_comparator_10
    Xmic_11 VSS VDD CLK VCM X0_P X1_P X2_P X3_P X4_P X5_P X6_P X7_P X8_P X9_P X10_P X11_P X0_N X1_N X2_N X3_N X4_N X5_N X6_N X7_N X8_N X9_N X10_N X11_N IN0_P IN1_P IN0_N IN1_N S0_P S1_P S2_P S3_P S4_P S5_P S6_P S7_P S8_P S9_P S10_P S11_P S12_P S13_P S0_N S1_N S2_N S3_N S4_N S5_N S6_N S7_N S8_N S9_N S10_N S11_N S12_N S13_N multi_input_comparator_11
    Xmic_12 VSS VDD CLK VCM X0_P X1_P X2_P X3_P X4_P X5_P X6_P X7_P X8_P X9_P X10_P X11_P X0_N X1_N X2_N X3_N X4_N X5_N X6_N X7_N X8_N X9_N X10_N X11_N IN0_P IN1_P IN0_N IN1_N S0_P S1_P S2_P S3_P S4_P S5_P S6_P S7_P S8_P S9_P S10_P S11_P S12_P S13_P S0_N S1_N S2_N S3_N S4_N S5_N S6_N S7_N S8_N S9_N S10_N S11_N S12_N S13_N multi_input_comparator_12
    Xmic_13 VSS VDD CLK VCM X0_P X1_P X2_P X3_P X4_P X5_P X6_P X7_P X8_P X9_P X10_P X11_P X0_N X1_N X2_N X3_N X4_N X5_N X6_N X7_N X8_N X9_N X10_N X11_N IN0_P IN1_P IN0_N IN1_N S0_P S1_P S2_P S3_P S4_P S5_P S6_P S7_P S8_P S9_P S10_P S11_P S12_P S13_P S0_N S1_N S2_N S3_N S4_N S5_N S6_N S7_N S8_N S9_N S10_N S11_N S12_N S13_N multi_input_comparator_13
.ENDS digital_control

.SUBCKT multi_input_comparator_2 VSS VDD CLK VCM X0_P X1_P X2_P X3_P X4_P X5_P X6_P X7_P X8_P X9_P X10_P X11_P X0_N X1_N X2_N X3_N X4_N X5_N X6_N X7_N X8_N X9_N X10_N X11_N IN0_P IN1_P IN0_N IN1_N S0_P S1_P S2_P S3_P S4_P S5_P S6_P S7_P S8_P S9_P S10_P S11_P S12_P S13_P S0_N S1_N S2_N S3_N S4_N S5_N S6_N S7_N S8_N S9_N S10_N S11_N S12_N S13_N
    As [%vd(X0_P,X0_N) %vd(X1_P,X1_N) %vd(X2_P,X2_N) %vd(X3_P,X3_N) %vd(X4_P,X4_N) %vd(X5_P,X5_N) %vd(X6_P,X6_N) %vd(X7_P,X7_N) %vd(X8_P,X8_N) %vd(X9_P,X9_N) %vd(X10_P,X10_N) %vd(X11_P,X11_N) %vd(IN0_P,IN0_N) %vd(IN1_P,IN1_N) %vd(S0_P,S0_N) %vd(S1_P,S1_N) %vd(S2_P,S2_N) %vd(S3_P,S3_N) %vd(S4_P,S4_N) %vd(S5_P,S5_N) %vd(S6_P,S6_N) %vd(S7_P,S7_N) %vd(S8_P,S8_N) %vd(S9_P,S9_N) %vd(S10_P,S10_N) %vd(S11_P,S11_N) %vd(S12_P,S12_N) %vd(S13_P,S13_N)] STILDE sum_0
    Xcomp CLK STILDE S2_P S2_N VCM clocked_comparator
.ENDS multi_input_comparator_2

.SUBCKT clocked_comparator CLK IN OUT_P OUT_N VCM
    Aclk_adc [%vd(CLK,VCM)] [CLKD] adc
    Ain_adc [%vd(IN,VCM)] [OUT] adc
    Adffp OUT CLKD SET RES F_OUT_P F_OUT_N dflip
    Adac_p [F_OUT_P] [OUT_P] dac
    Adac_n [F_OUT_N] [OUT_N] dac
.ENDS clocked_comparator

.SUBCKT multi_input_comparator_3 VSS VDD CLK VCM X0_P X1_P X2_P X3_P X4_P X5_P X6_P X7_P X8_P X9_P X10_P X11_P X0_N X1_N X2_N X3_N X4_N X5_N X6_N X7_N X8_N X9_N X10_N X11_N IN0_P IN1_P IN0_N IN1_N S0_P S1_P S2_P S3_P S4_P S5_P S6_P S7_P S8_P S9_P S10_P S11_P S12_P S13_P S0_N S1_N S2_N S3_N S4_N S5_N S6_N S7_N S8_N S9_N S10_N S11_N S12_N S13_N
    As [%vd(X0_P,X0_N) %vd(X1_P,X1_N) %vd(X2_P,X2_N) %vd(X3_P,X3_N) %vd(X4_P,X4_N) %vd(X5_P,X5_N) %vd(X6_P,X6_N) %vd(X7_P,X7_N) %vd(X8_P,X8_N) %vd(X9_P,X9_N) %vd(X10_P,X10_N) %vd(X11_P,X11_N) %vd(IN0_P,IN0_N) %vd(IN1_P,IN1_N) %vd(S0_P,S0_N) %vd(S1_P,S1_N) %vd(S2_P,S2_N) %vd(S3_P,S3_N) %vd(S4_P,S4_N) %vd(S5_P,S5_N) %vd(S6_P,S6_N) %vd(S7_P,S7_N) %vd(S8_P,S8_N) %vd(S9_P,S9_N) %vd(S10_P,S10_N) %vd(S11_P,S11_N) %vd(S12_P,S12_N) %vd(S13_P,S13_N)] STILDE sum_1
    Xcomp CLK STILDE S3_P S3_N VCM clocked_comparator
.ENDS multi_input_comparator_3

.SUBCKT multi_input_comparator_4 VSS VDD CLK VCM X0_P X1_P X2_P X3_P X4_P X5_P X6_P X7_P X8_P X9_P X10_P X11_P X0_N X1_N X2_N X3_N X4_N X5_N X6_N X7_N X8_N X9_N X10_N X11_N IN0_P IN1_P IN0_N IN1_N S0_P S1_P S2_P S3_P S4_P S5_P S6_P S7_P S8_P S9_P S10_P S11_P S12_P S13_P S0_N S1_N S2_N S3_N S4_N S5_N S6_N S7_N S8_N S9_N S10_N S11_N S12_N S13_N
    As [%vd(X0_P,X0_N) %vd(X1_P,X1_N) %vd(X2_P,X2_N) %vd(X3_P,X3_N) %vd(X4_P,X4_N) %vd(X5_P,X5_N) %vd(X6_P,X6_N) %vd(X7_P,X7_N) %vd(X8_P,X8_N) %vd(X9_P,X9_N) %vd(X10_P,X10_N) %vd(X11_P,X11_N) %vd(IN0_P,IN0_N) %vd(IN1_P,IN1_N) %vd(S0_P,S0_N) %vd(S1_P,S1_N) %vd(S2_P,S2_N) %vd(S3_P,S3_N) %vd(S4_P,S4_N) %vd(S5_P,S5_N) %vd(S6_P,S6_N) %vd(S7_P,S7_N) %vd(S8_P,S8_N) %vd(S9_P,S9_N) %vd(S10_P,S10_N) %vd(S11_P,S11_N) %vd(S12_P,S12_N) %vd(S13_P,S13_N)] STILDE sum_2
    Xcomp CLK STILDE S4_P S4_N VCM clocked_comparator
.ENDS multi_input_comparator_4

.SUBCKT multi_input_comparator_5 VSS VDD CLK VCM X0_P X1_P X2_P X3_P X4_P X5_P X6_P X7_P X8_P X9_P X10_P X11_P X0_N X1_N X2_N X3_N X4_N X5_N X6_N X7_N X8_N X9_N X10_N X11_N IN0_P IN1_P IN0_N IN1_N S0_P S1_P S2_P S3_P S4_P S5_P S6_P S7_P S8_P S9_P S10_P S11_P S12_P S13_P S0_N S1_N S2_N S3_N S4_N S5_N S6_N S7_N S8_N S9_N S10_N S11_N S12_N S13_N
    As [%vd(X0_P,X0_N) %vd(X1_P,X1_N) %vd(X2_P,X2_N) %vd(X3_P,X3_N) %vd(X4_P,X4_N) %vd(X5_P,X5_N) %vd(X6_P,X6_N) %vd(X7_P,X7_N) %vd(X8_P,X8_N) %vd(X9_P,X9_N) %vd(X10_P,X10_N) %vd(X11_P,X11_N) %vd(IN0_P,IN0_N) %vd(IN1_P,IN1_N) %vd(S0_P,S0_N) %vd(S1_P,S1_N) %vd(S2_P,S2_N) %vd(S3_P,S3_N) %vd(S4_P,S4_N) %vd(S5_P,S5_N) %vd(S6_P,S6_N) %vd(S7_P,S7_N) %vd(S8_P,S8_N) %vd(S9_P,S9_N) %vd(S10_P,S10_N) %vd(S11_P,S11_N) %vd(S12_P,S12_N) %vd(S13_P,S13_N)] STILDE sum_3
    Xcomp CLK STILDE S5_P S5_N VCM clocked_comparator
.ENDS multi_input_comparator_5

.SUBCKT multi_input_comparator_6 VSS VDD CLK VCM X0_P X1_P X2_P X3_P X4_P X5_P X6_P X7_P X8_P X9_P X10_P X11_P X0_N X1_N X2_N X3_N X4_N X5_N X6_N X7_N X8_N X9_N X10_N X11_N IN0_P IN1_P IN0_N IN1_N S0_P S1_P S2_P S3_P S4_P S5_P S6_P S7_P S8_P S9_P S10_P S11_P S12_P S13_P S0_N S1_N S2_N S3_N S4_N S5_N S6_N S7_N S8_N S9_N S10_N S11_N S12_N S13_N
    As [%vd(X0_P,X0_N) %vd(X1_P,X1_N) %vd(X2_P,X2_N) %vd(X3_P,X3_N) %vd(X4_P,X4_N) %vd(X5_P,X5_N) %vd(X6_P,X6_N) %vd(X7_P,X7_N) %vd(X8_P,X8_N) %vd(X9_P,X9_N) %vd(X10_P,X10_N) %vd(X11_P,X11_N) %vd(IN0_P,IN0_N) %vd(IN1_P,IN1_N) %vd(S0_P,S0_N) %vd(S1_P,S1_N) %vd(S2_P,S2_N) %vd(S3_P,S3_N) %vd(S4_P,S4_N) %vd(S5_P,S5_N) %vd(S6_P,S6_N) %vd(S7_P,S7_N) %vd(S8_P,S8_N) %vd(S9_P,S9_N) %vd(S10_P,S10_N) %vd(S11_P,S11_N) %vd(S12_P,S12_N) %vd(S13_P,S13_N)] STILDE sum_4
    Xcomp CLK STILDE S6_P S6_N VCM clocked_comparator
.ENDS multi_input_comparator_6

.SUBCKT multi_input_comparator_7 VSS VDD CLK VCM X0_P X1_P X2_P X3_P X4_P X5_P X6_P X7_P X8_P X9_P X10_P X11_P X0_N X1_N X2_N X3_N X4_N X5_N X6_N X7_N X8_N X9_N X10_N X11_N IN0_P IN1_P IN0_N IN1_N S0_P S1_P S2_P S3_P S4_P S5_P S6_P S7_P S8_P S9_P S10_P S11_P S12_P S13_P S0_N S1_N S2_N S3_N S4_N S5_N S6_N S7_N S8_N S9_N S10_N S11_N S12_N S13_N
    As [%vd(X0_P,X0_N) %vd(X1_P,X1_N) %vd(X2_P,X2_N) %vd(X3_P,X3_N) %vd(X4_P,X4_N) %vd(X5_P,X5_N) %vd(X6_P,X6_N) %vd(X7_P,X7_N) %vd(X8_P,X8_N) %vd(X9_P,X9_N) %vd(X10_P,X10_N) %vd(X11_P,X11_N) %vd(IN0_P,IN0_N) %vd(IN1_P,IN1_N) %vd(S0_P,S0_N) %vd(S1_P,S1_N) %vd(S2_P,S2_N) %vd(S3_P,S3_N) %vd(S4_P,S4_N) %vd(S5_P,S5_N) %vd(S6_P,S6_N) %vd(S7_P,S7_N) %vd(S8_P,S8_N) %vd(S9_P,S9_N) %vd(S10_P,S10_N) %vd(S11_P,S11_N) %vd(S12_P,S12_N) %vd(S13_P,S13_N)] STILDE sum_5
    Xcomp CLK STILDE S7_P S7_N VCM clocked_comparator
.ENDS multi_input_comparator_7

.SUBCKT multi_input_comparator_8 VSS VDD CLK VCM X0_P X1_P X2_P X3_P X4_P X5_P X6_P X7_P X8_P X9_P X10_P X11_P X0_N X1_N X2_N X3_N X4_N X5_N X6_N X7_N X8_N X9_N X10_N X11_N IN0_P IN1_P IN0_N IN1_N S0_P S1_P S2_P S3_P S4_P S5_P S6_P S7_P S8_P S9_P S10_P S11_P S12_P S13_P S0_N S1_N S2_N S3_N S4_N S5_N S6_N S7_N S8_N S9_N S10_N S11_N S12_N S13_N
    As [%vd(X0_P,X0_N) %vd(X1_P,X1_N) %vd(X2_P,X2_N) %vd(X3_P,X3_N) %vd(X4_P,X4_N) %vd(X5_P,X5_N) %vd(X6_P,X6_N) %vd(X7_P,X7_N) %vd(X8_P,X8_N) %vd(X9_P,X9_N) %vd(X10_P,X10_N) %vd(X11_P,X11_N) %vd(IN0_P,IN0_N) %vd(IN1_P,IN1_N) %vd(S0_P,S0_N) %vd(S1_P,S1_N) %vd(S2_P,S2_N) %vd(S3_P,S3_N) %vd(S4_P,S4_N) %vd(S5_P,S5_N) %vd(S6_P,S6_N) %vd(S7_P,S7_N) %vd(S8_P,S8_N) %vd(S9_P,S9_N) %vd(S10_P,S10_N) %vd(S11_P,S11_N) %vd(S12_P,S12_N) %vd(S13_P,S13_N)] STILDE sum_6
    Xcomp CLK STILDE S8_P S8_N VCM clocked_comparator
.ENDS multi_input_comparator_8

.SUBCKT multi_input_comparator_9 VSS VDD CLK VCM X0_P X1_P X2_P X3_P X4_P X5_P X6_P X7_P X8_P X9_P X10_P X11_P X0_N X1_N X2_N X3_N X4_N X5_N X6_N X7_N X8_N X9_N X10_N X11_N IN0_P IN1_P IN0_N IN1_N S0_P S1_P S2_P S3_P S4_P S5_P S6_P S7_P S8_P S9_P S10_P S11_P S12_P S13_P S0_N S1_N S2_N S3_N S4_N S5_N S6_N S7_N S8_N S9_N S10_N S11_N S12_N S13_N
    As [%vd(X0_P,X0_N) %vd(X1_P,X1_N) %vd(X2_P,X2_N) %vd(X3_P,X3_N) %vd(X4_P,X4_N) %vd(X5_P,X5_N) %vd(X6_P,X6_N) %vd(X7_P,X7_N) %vd(X8_P,X8_N) %vd(X9_P,X9_N) %vd(X10_P,X10_N) %vd(X11_P,X11_N) %vd(IN0_P,IN0_N) %vd(IN1_P,IN1_N) %vd(S0_P,S0_N) %vd(S1_P,S1_N) %vd(S2_P,S2_N) %vd(S3_P,S3_N) %vd(S4_P,S4_N) %vd(S5_P,S5_N) %vd(S6_P,S6_N) %vd(S7_P,S7_N) %vd(S8_P,S8_N) %vd(S9_P,S9_N) %vd(S10_P,S10_N) %vd(S11_P,S11_N) %vd(S12_P,S12_N) %vd(S13_P,S13_N)] STILDE sum_7
    Xcomp CLK STILDE S9_P S9_N VCM clocked_comparator
.ENDS multi_input_comparator_9

.SUBCKT multi_input_comparator_10 VSS VDD CLK VCM X0_P X1_P X2_P X3_P X4_P X5_P X6_P X7_P X8_P X9_P X10_P X11_P X0_N X1_N X2_N X3_N X4_N X5_N X6_N X7_N X8_N X9_N X10_N X11_N IN0_P IN1_P IN0_N IN1_N S0_P S1_P S2_P S3_P S4_P S5_P S6_P S7_P S8_P S9_P S10_P S11_P S12_P S13_P S0_N S1_N S2_N S3_N S4_N S5_N S6_N S7_N S8_N S9_N S10_N S11_N S12_N S13_N
    As [%vd(X0_P,X0_N) %vd(X1_P,X1_N) %vd(X2_P,X2_N) %vd(X3_P,X3_N) %vd(X4_P,X4_N) %vd(X5_P,X5_N) %vd(X6_P,X6_N) %vd(X7_P,X7_N) %vd(X8_P,X8_N) %vd(X9_P,X9_N) %vd(X10_P,X10_N) %vd(X11_P,X11_N) %vd(IN0_P,IN0_N) %vd(IN1_P,IN1_N) %vd(S0_P,S0_N) %vd(S1_P,S1_N) %vd(S2_P,S2_N) %vd(S3_P,S3_N) %vd(S4_P,S4_N) %vd(S5_P,S5_N) %vd(S6_P,S6_N) %vd(S7_P,S7_N) %vd(S8_P,S8_N) %vd(S9_P,S9_N) %vd(S10_P,S10_N) %vd(S11_P,S11_N) %vd(S12_P,S12_N) %vd(S13_P,S13_N)] STILDE sum_8
    Xcomp CLK STILDE S10_P S10_N VCM clocked_comparator
.ENDS multi_input_comparator_10

.SUBCKT multi_input_comparator_11 VSS VDD CLK VCM X0_P X1_P X2_P X3_P X4_P X5_P X6_P X7_P X8_P X9_P X10_P X11_P X0_N X1_N X2_N X3_N X4_N X5_N X6_N X7_N X8_N X9_N X10_N X11_N IN0_P IN1_P IN0_N IN1_N S0_P S1_P S2_P S3_P S4_P S5_P S6_P S7_P S8_P S9_P S10_P S11_P S12_P S13_P S0_N S1_N S2_N S3_N S4_N S5_N S6_N S7_N S8_N S9_N S10_N S11_N S12_N S13_N
    As [%vd(X0_P,X0_N) %vd(X1_P,X1_N) %vd(X2_P,X2_N) %vd(X3_P,X3_N) %vd(X4_P,X4_N) %vd(X5_P,X5_N) %vd(X6_P,X6_N) %vd(X7_P,X7_N) %vd(X8_P,X8_N) %vd(X9_P,X9_N) %vd(X10_P,X10_N) %vd(X11_P,X11_N) %vd(IN0_P,IN0_N) %vd(IN1_P,IN1_N) %vd(S0_P,S0_N) %vd(S1_P,S1_N) %vd(S2_P,S2_N) %vd(S3_P,S3_N) %vd(S4_P,S4_N) %vd(S5_P,S5_N) %vd(S6_P,S6_N) %vd(S7_P,S7_N) %vd(S8_P,S8_N) %vd(S9_P,S9_N) %vd(S10_P,S10_N) %vd(S11_P,S11_N) %vd(S12_P,S12_N) %vd(S13_P,S13_N)] STILDE sum_9
    Xcomp CLK STILDE S11_P S11_N VCM clocked_comparator
.ENDS multi_input_comparator_11

.SUBCKT multi_input_comparator_12 VSS VDD CLK VCM X0_P X1_P X2_P X3_P X4_P X5_P X6_P X7_P X8_P X9_P X10_P X11_P X0_N X1_N X2_N X3_N X4_N X5_N X6_N X7_N X8_N X9_N X10_N X11_N IN0_P IN1_P IN0_N IN1_N S0_P S1_P S2_P S3_P S4_P S5_P S6_P S7_P S8_P S9_P S10_P S11_P S12_P S13_P S0_N S1_N S2_N S3_N S4_N S5_N S6_N S7_N S8_N S9_N S10_N S11_N S12_N S13_N
    As [%vd(X0_P,X0_N) %vd(X1_P,X1_N) %vd(X2_P,X2_N) %vd(X3_P,X3_N) %vd(X4_P,X4_N) %vd(X5_P,X5_N) %vd(X6_P,X6_N) %vd(X7_P,X7_N) %vd(X8_P,X8_N) %vd(X9_P,X9_N) %vd(X10_P,X10_N) %vd(X11_P,X11_N) %vd(IN0_P,IN0_N) %vd(IN1_P,IN1_N) %vd(S0_P,S0_N) %vd(S1_P,S1_N) %vd(S2_P,S2_N) %vd(S3_P,S3_N) %vd(S4_P,S4_N) %vd(S5_P,S5_N) %vd(S6_P,S6_N) %vd(S7_P,S7_N) %vd(S8_P,S8_N) %vd(S9_P,S9_N) %vd(S10_P,S10_N) %vd(S11_P,S11_N) %vd(S12_P,S12_N) %vd(S13_P,S13_N)] STILDE sum_10
    Xcomp CLK STILDE S12_P S12_N VCM clocked_comparator
.ENDS multi_input_comparator_12

.SUBCKT multi_input_comparator_13 VSS VDD CLK VCM X0_P X1_P X2_P X3_P X4_P X5_P X6_P X7_P X8_P X9_P X10_P X11_P X0_N X1_N X2_N X3_N X4_N X5_N X6_N X7_N X8_N X9_N X10_N X11_N IN0_P IN1_P IN0_N IN1_N S0_P S1_P S2_P S3_P S4_P S5_P S6_P S7_P S8_P S9_P S10_P S11_P S12_P S13_P S0_N S1_N S2_N S3_N S4_N S5_N S6_N S7_N S8_N S9_N S10_N S11_N S12_N S13_N
    As [%vd(X0_P,X0_N) %vd(X1_P,X1_N) %vd(X2_P,X2_N) %vd(X3_P,X3_N) %vd(X4_P,X4_N) %vd(X5_P,X5_N) %vd(X6_P,X6_N) %vd(X7_P,X7_N) %vd(X8_P,X8_N) %vd(X9_P,X9_N) %vd(X10_P,X10_N) %vd(X11_P,X11_N) %vd(IN0_P,IN0_N) %vd(IN1_P,IN1_N) %vd(S0_P,S0_N) %vd(S1_P,S1_N) %vd(S2_P,S2_N) %vd(S3_P,S3_N) %vd(S4_P,S4_N) %vd(S5_P,S5_N) %vd(S6_P,S6_N) %vd(S7_P,S7_N) %vd(S8_P,S8_N) %vd(S9_P,S9_N) %vd(S10_P,S10_N) %vd(S11_P,S11_N) %vd(S12_P,S12_N) %vd(S13_P,S13_N)] STILDE sum_11
    Xcomp CLK STILDE S13_P S13_N VCM clocked_comparator
.ENDS multi_input_comparator_13

.SUBCKT opamp VDD VSS VCM IN_P IN_N OUT_P OUT_N
    Gota X VCM IN_P IN_N 0.008997896673311382
    Ebuf_p OUT_P VCM X VCM 1.0
    Ebuf_n OUT_N VCM VCM X 1.0
    Rx X VCM r=70752.06523051728
    Cx X VCM 1e-14
.ENDS opamp

* model definitions

.model sum_0 summer(in_offset=[0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0] in_gain=[-1.1111404660392046, -0.0, -0.0, -0.0, -0.0, -0.0, 1.6629392246050905, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0] out_offset=0.5 out_gain=1.0)
.model adc adc_bridge(in_low=0.0 in_high=0.0 rise_delay=4.656612873077393e-13 fall_delay=4.656612873077393e-13)
.model dflip d_dff(clk_delay=0.0 set_delay=1e-15 reset_delay=1e-15 ic=1 rise_delay=4.656612873077393e-13 fall_delay=4.656612873077393e-13)
.model dac dac_bridge(out_low=0.0 out_high=1.0 out_undef=0.5 input_load=1e-12 t_rise=4.656612873077393e-12 t_fall=4.656612873077393e-12)
.model sum_1 summer(in_offset=[0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0] in_gain=[-0.0, -1.1111404660392046, -0.0, -0.0, -0.0, -0.0, 0.0, 1.6629392246050905, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0] out_offset=0.5 out_gain=1.0)
.model sum_2 summer(in_offset=[0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0] in_gain=[-0.0, -0.0, -1.1111404660392046, -0.0, -0.0, -0.0, 0.0, 0.0, 1.6629392246050905, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0] out_offset=0.5 out_gain=1.0)
.model sum_3 summer(in_offset=[0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0] in_gain=[-0.0, -0.0, -0.0, -1.1111404660392046, -0.0, -0.0, 0.0, 0.0, 0.0, 1.6629392246050905, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0] out_offset=0.5 out_gain=1.0)
.model sum_4 summer(in_offset=[0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0] in_gain=[-0.0, -0.0, -0.0, -0.0, -1.1111404660392046, -0.0, 0.0, 0.0, 0.0, 0.0, 1.6629392246050905, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0] out_offset=0.5 out_gain=1.0)
.model sum_5 summer(in_offset=[0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0] in_gain=[-0.0, -0.0, -0.0, -0.0, -0.0, -1.1111404660392046, 0.0, 0.0, 0.0, 0.0, 0.0, 1.6629392246050905, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0] out_offset=0.5 out_gain=1.0)
.model sum_6 summer(in_offset=[0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0] in_gain=[-1.6629392246050905, -0.0, -0.0, -0.0, -0.0, -0.0, -1.1111404660392046, -0.0, -0.0, -0.0, -0.0, -0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0] out_offset=0.5 out_gain=1.0)
.model sum_7 summer(in_offset=[0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0] in_gain=[-0.0, -1.6629392246050905, -0.0, -0.0, -0.0, -0.0, -0.0, -1.1111404660392046, -0.0, -0.0, -0.0, -0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0] out_offset=0.5 out_gain=1.0)
.model sum_8 summer(in_offset=[0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0] in_gain=[-0.0, -0.0, -1.6629392246050905, -0.0, -0.0, -0.0, -0.0, -0.0, -1.1111404660392046, -0.0, -0.0, -0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0] out_offset=0.5 out_gain=1.0)
.model sum_9 summer(in_offset=[0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0] in_gain=[-0.0, -0.0, -0.0, -1.6629392246050905, -0.0, -0.0, -0.0, -0.0, -0.0, -1.1111404660392046, -0.0, -0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0] out_offset=0.5 out_gain=1.0)
.model sum_10 summer(in_offset=[0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0] in_gain=[-0.0, -0.0, -0.0, -0.0, -1.6629392246050905, -0.0, -0.0, -0.0, -0.0, -0.0, -1.1111404660392046, -0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0] out_offset=0.5 out_gain=1.0)
.model sum_11 summer(in_offset=[0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0] in_gain=[-0.0, -0.0, -0.0, -0.0, -0.0, -1.6629392246050905, -0.0, -0.0, -0.0, -0.0, -0.0, -1.1111404660392046, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0] out_offset=0.5 out_gain=1.0)
.model r_source d_source(input_file="dither_sequence_8759199555699.txt")

********************************************
********** spice analysis command **********
********************************************

* AC analysis of analog system
* .ac dec 256 1000.0 10000000.0
* .control
* run
* plot vdb(Xaf.X0_P, Xaf.X0_N) vdb(Xaf.X1_P, Xaf.X1_N) vdb(Xaf.X2_P, Xaf.X2_N) vdb(Xaf.X3_P, Xaf.X3_N) vdb(Xaf.X4_P, Xaf.X4_N) vdb(Xaf.X5_P, Xaf.X5_N) vdb(Xaf.X6_P, Xaf.X6_N) vdb(Xaf.X7_P, Xaf.X7_N) vdb(Xaf.X8_P, Xaf.X8_N) vdb(Xaf.X9_P, Xaf.X9_N) vdb(Xaf.X10_P, Xaf.X10_N) vdb(Xaf.X11_P, Xaf.X11_N) xlog
* .endc

* Transient analysis of state trajectories
.tran 4.656612873077393e-10 7.62939453125e-06 0.0 4.656612873077393e-10 UIC
* .control
* run
* plot the differential state trajectories
* plot v(Xaf.X11_P, Xaf.X11_N) v(Xaf.X10_P, Xaf.X10_N) v(Xaf.X9_P, Xaf.X9_N) v(Xaf.X8_P, Xaf.X8_N) v(Xaf.X7_P, Xaf.X7_N) v(Xaf.X6_P, Xaf.X6_N) v(Xaf.X5_P, Xaf.X5_N) v(Xaf.X4_P, Xaf.X4_N) v(Xaf.X3_P, Xaf.X3_N) v(Xaf.X2_P, Xaf.X2_N) v(Xaf.X1_P, Xaf.X1_N) v(Xaf.X0_P, Xaf.X0_N)* plot the single ended state trajectories
* plot v(Xaf.X11_P) v(Xaf.X10_P) v(Xaf.X9_P) v(Xaf.X8_P) v(Xaf.X7_P) v(Xaf.X6_P) v(Xaf.X5_P) v(Xaf.X4_P) v(Xaf.X3_P) v(Xaf.X2_P) v(Xaf.X1_P) v(Xaf.X0_P)
* .endc

.options reltol=0.0001
.options opts
.options warn=1
.options ACCT

.save V(CLK) V(OUT0_P) V(OUT1_P) V(OUT2_P) V(OUT3_P) V(OUT4_P) V(OUT5_P) V(OUT6_P) V(OUT7_P) V(OUT8_P) V(OUT9_P) V(OUT10_P) V(OUT11_P) V(OUT12_P) V(OUT13_P) V(OUT0_N) V(OUT1_N) V(OUT2_N) V(OUT3_N) V(OUT4_N) V(OUT5_N) V(OUT6_N) V(OUT7_N) V(OUT8_N) V(OUT9_N) V(OUT10_N) V(OUT11_N) V(OUT12_N) V(OUT13_N) V(IN0_P) V(IN1_P) V(IN0_N) V(IN1_N) V(Xaf.X0_P) V(Xaf.X1_P) V(Xaf.X2_P) V(Xaf.X3_P) V(Xaf.X4_P) V(Xaf.X5_P) V(Xaf.X6_P) V(Xaf.X7_P) V(Xaf.X8_P) V(Xaf.X9_P) V(Xaf.X10_P) V(Xaf.X11_P) V(Xaf.X0_N) V(Xaf.X1_N) V(Xaf.X2_N) V(Xaf.X3_N) V(Xaf.X4_N) V(Xaf.X5_N) V(Xaf.X6_N) V(Xaf.X7_N) V(Xaf.X8_N) V(Xaf.X9_N) V(Xaf.X10_N) V(Xaf.X11_N)
.end
